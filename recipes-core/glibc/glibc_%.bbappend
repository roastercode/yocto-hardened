require glibc-version.inc
PV = "2.41"
