# CVE-2000-0006 : faux positif, non applicable à strace moderne
CVE_CHECK_IGNORE += "CVE-2000-0006"
