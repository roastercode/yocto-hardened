# Fix compilation with GCC 15
CFLAGS:append = " -std=gnu17"
