CFLAGS:append:class-native = " -std=gnu17"
